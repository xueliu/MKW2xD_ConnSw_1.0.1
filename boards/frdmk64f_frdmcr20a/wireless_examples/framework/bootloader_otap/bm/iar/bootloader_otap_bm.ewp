# IAR project bootloader_otap_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; gEepromType_d=gEepromDevice_InternalFlash_c; gUseOTAPBootloader_d=1; CPU_MK64FN1M0VMD12; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../src/bootloader; ../../src/eeprom; ../../src/flash; ../../src/config; ../../src/spi; ../../src/timer; ../../src/uart; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12; ../../../../../../../middleware/wireless/framework_5.0.5/Common; ../../../../../../../devices/MK64F12/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bootloader_otap_frdmk64f_frdmcr20a.bin
  ILINK.IlinkOutputFile: bootloader_otap_bm.out
  ILINK.IlinkConfigDefines: gRomSize_c=1048576; gSectorSize_c=4096
  ILINK.IlinkIcfFile: Bootloader.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; gEepromType_d=gEepromDevice_InternalFlash_c; gUseOTAPBootloader_d=1; CPU_MK64FN1M0VMD12; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group source
    ../../src/bootloader/: main.c main.h OtapBootloader.c OtapBootloader.h
  group source/drivers/eeprom
    ../../src/eeprom/: Eeprom_Boot.h Eeprom_Boot_InternalFlash.c
  group source/drivers/flash
    ../../src/flash/: flash_boot_kinetis.c flash_boot_kinetis.h
  group source/drivers/spi
    ../../src/spi/: SPI.c SPI.h
  group source/drivers/timer
    ../../src/timer/: timer.c timer.h
  group source/drivers/uart
    ../../src/uart/: UART.c UART.h
  group source/config
    ../../src/config/: frdmk64f_cfg.h
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/: EmbeddedTypes.h
  group utilities
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
