# IAR project otap_server_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: ../../../../../../../boards/frdmk64f_frdmcr20a/wireless_examples/ieee_802_15_4/otap_server/freertos/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config; ../../../../../../../rtos/freertos_8.2.3/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/mmcau_2.0.0; ../../../../../../../middleware/usb_1.1.0; ../../../../../../../middleware/usb_1.1.0/osa; ../../../../../../../middleware/usb_1.1.0/include; ../../../../../../../middleware/usb_1.1.0/device; ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/interface; ../../../../../../../middleware/wireless/framework_5.0.5/GPIO; ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/LED/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.0.5/Common; ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.0.5/FunctionLib; ../../../../../../../middleware/wireless/framework_5.0.5/Lists; ../../../../../../../middleware/wireless/framework_5.0.5/SecLib; ../../../../../../../middleware/wireless/framework_5.0.5/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Interface; ../..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/examples/common; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/MCR20Drv; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/XcvrSpi; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom; ../../../../../../../devices/MK64F12; ../../../../../../../devices/MK64F12/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config
  OBJCOPY.OOCOutputFile: otap_server_frdmk64f_frdmcr20a.bin
  ILINK.IlinkOutputFile: otap_server_freertos.out
  ILINK.IlinkConfigDefines: gUseInternalStorageLink_d=1
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/mmcau_2.0.0/asm-cm4-cm7/lib_mmcau.a; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/lib/802.15.4_mac_06_cM4.a; ../../../../../../../middleware/wireless/framework_5.0.5/SecLib/lib_crypto_M4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb/osa
    ../../../../../../../middleware/usb_1.1.0/osa/: usb_osa_freertos.h usb_osa_freertos.c
  group usb/device/source
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../../middleware/usb_1.1.0/include/: usb_khci.h
  group usb/device/include
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device.h
  group usb/include
    ../../../../../../../middleware/usb_1.1.0/include/: usb.h usb_misc.h usb_spec.h
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Source/USB_VirtualCom/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom/: VirtualComInterface.h
  group framework/SerialManager/Source/USB_VirtualCom/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom/: usb_device_cdc_acm.h usb_device_cdc_acm.c usb_device_ch9.h usb_device_ch9.c usb_device_class.h usb_device_class.c usb_device_config.h usb_device_descriptor.h usb_device_descriptor.c virtual_com.h virtual_com.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Interface/: SerialManager.h
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/: EmbeddedTypes.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Source/: FSCICommands.c FSCICommands.h FSCICommunication.c FSCICommunication.h FSCILogging.c FsciMain.c
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Source/: OtaSupport.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.0.5/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.0.5/Lists/: GenericList.c GenericList.h
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.0.5/ModuleInfo/: ModuleInfo.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.0.5/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Source/: MWS.c
  group source
    ../: app_preinclude.h
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config/: FreeRTOSConfig.h
    ../../: otap_server.c otap_server.h OtaMessages.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h hardware_init.c
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/: Phy.h ASP.c MPM.c PhyDebug.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group ieee_802.15.4/phy/source/MCR20A/MCR20Drv
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/MCR20Drv/: MCR20Drv.c MCR20Drv.h MCR20Reg.h MCR20Overwrites.h
  group ieee_802.15.4/phy/source/XcvrSPI
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/XcvrSpi/: Spi.c Spi.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_common.h fsl_common.c fsl_rnga.c fsl_rnga.h fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_ftm.c fsl_ftm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_mpu.h fsl_mpu.c fsl_smc.h fsl_smc.c fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c
  group mmcau/mmcau_include
    ../../../../../../../middleware/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../../../middleware/mmcau_2.0.0/: fsl_mmcau.c
  group utilities
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
