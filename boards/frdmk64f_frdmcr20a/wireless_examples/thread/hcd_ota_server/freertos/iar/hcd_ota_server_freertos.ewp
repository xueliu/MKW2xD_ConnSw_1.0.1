# IAR project hcd_ota_server_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/hcd_ota_server/config/config.h
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config; ../../../../../../../rtos/freertos_8.2.3/Source; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/mmcau_2.0.0; ../../../../../../../middleware/usb_1.1.0; ../../../../../../../middleware/usb_1.1.0/osa; ../../../../../../../middleware/usb_1.1.0/include; ../../../../../../../middleware/usb_1.1.0/device; ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/source/App; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/interface; ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/GPIO; ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/LED/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.0.5/Common; ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.0.5/FunctionLib; ../../../../../../../middleware/wireless/framework_5.0.5/Lists; ../../../../../../../middleware/wireless/framework_5.0.5/SecLib; ../../../../../../../middleware/wireless/framework_5.0.5/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/Shell/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/NVM/Source; ../../../../../../../middleware/wireless/framework_5.0.5/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.0.5/LowPower/Interface/K64F_MCR20; ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface/modules; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface/thread; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/common; ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/hcd_ota_server/src; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/MCR20Drv; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/XcvrSpi; ../../../../../../../devices/MK64F12; ../../../../../../../devices/MK64F12/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config
  OBJCOPY.OOCOutputFile: hcd_ota_server_freertos_frdmk64f_frdmcr20a.srec
  ILINK.IlinkOutputFile: hcd_ota_server_freertos.out
  ILINK.IlinkConfigDefines: gUseBootloaderLink_d=0; gUseNVMLink_d=1; __ram_vector_table__=1; gUseInternalStorageLink_d=0; gNVMSectorCountLink_d=32; gEraseNVMLink_d=1
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/lib/thread/thread_br_iar_cM4.a; ../../../../../../../middleware/mmcau_2.0.0/asm-cm4-cm7/lib_mmcau.a; ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/lib/802.15.4_mac_thr_cM4.a; ../../../../../../../middleware/wireless/framework_5.0.5/SecLib/lib_crypto_M4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F_MCR20A; FRDM_K64F; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group freertos
    ../../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h
    ../../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group startup
    ../../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb/osa
    ../../../../../../../middleware/usb_1.1.0/osa/: usb_osa_freertos.h usb_osa_freertos.c
  group usb/device/source
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../../middleware/usb_1.1.0/include/: usb_khci.h
  group usb/device/include
    ../../../../../../../middleware/usb_1.1.0/device/: usb_device.h
  group usb/include
    ../../../../../../../middleware/usb_1.1.0/include/: usb.h usb_misc.h usb_spec.h
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.h
    ../../../../../../../middleware/wireless/framework_5.0.5/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/Flash/External/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB041E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.0.5/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/: UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Source/USB_VirtualCom/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom/: VirtualComInterface.h
  group framework/SerialManager/Source/USB_VirtualCom/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Source/USB_VirtualCom/: usb_device_cdc_acm.h usb_device_cdc_acm.c usb_device_ch9.h usb_device_ch9.c usb_device_class.h usb_device_class.c usb_device_config.h usb_device_descriptor.h usb_device_descriptor.c virtual_com.h virtual_com.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/SerialManager/Interface/: SerialManager.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.0.5/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.0.5/Lists/: GenericList.c GenericList.h
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.0.5/ModuleInfo/: ModuleInfo.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.0.5/SecLib/: SecLib.h SecLib.c
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/MWSCoexistence/Source/: MWS.c
  group framework/Shell/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/FSCI/Source/: FSCICommands.c FSCICommands.h FSCICommunication.c FSCICommunication.h FSCILogging.c FsciMain.c
  group framework/LowPower/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/LowPower/Interface/K64F_MCR20/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/LowPower/Source/K64F_MCR20/: PWR.c PWRLib.c PWRLib.h
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.0.5/OtaSupport/Source/: OtaSupport.c
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h hardware_init.c fsl_phy.h fsl_phy.c
  group source
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/rtos/FreeRTOS/config/: FreeRTOSConfig.h
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/hcd_ota_server/config/: config.h
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/hcd_ota_server/src/: hcd_ota_server_app.c hcd_ota_server_app.h
  group ieee_802.15.4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/source/App/: FsciAspCommands.h FsciAspCommands.c FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/mac/interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/mac/interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/phy/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/phy/source
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/: Phy.h ASP.c MPM.c PhyDebug.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group ieee_802.15.4/phy/source/MCR20A/MCR20Drv
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/MCR20A/MCR20Drv/: MCR20Drv.c MCR20Drv.h MCR20Reg.h MCR20Overwrites.h
  group ieee_802.15.4/phy/source/XcvrSPI
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.0.5/phy/source/XcvrSpi/: Spi.c Spi.h
  group nwk_ip/base/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/interface/: debug_log.h http.h http_cfg.h ip_if_6LowPan.h ip_if_enet.h ip_if_serial_tun.h mac_abs_802154.h mac_abs_types.h mac_filtering.h mac_filtering_cfg.h nv_data.h nvm_adapter.h shell_ip.h thci.h ip_if_serial_tun.h serial_tun_driver.h
  group nwk_ip/base/ip_media_if
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/ip_media_if/: ip_if_6lo.c ip_if_enet.c ip_if_usbenet.c ip_if_serial_tun.c serial_tun_driver.c
  group nwk_ip/base/shell
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/shell/: shell_ip.c
  group nwk_ip/base/stack_globals
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/stack_globals/: arp_globals.c coap_globals.c dhcp_globals.c dns_globals.c dtls_globals.c event_manager_globals.c icmp_globals.c ip_globals.c mdns_globals.c mle_globals.c mpl_globals.c nd_globals.c sixlowpan_globals.c sockets_globals.c tcp_globals.c thread_globals.c trickle_globals.c udp_globals.c
  group nwk_ip/base/thci
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/thci/: thci.c
  group nwk_ip/base/thread_config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/thread_config/: thread_config.c
  group nwk_ip/base/utils
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/base/utils/: debug_log.c HwFault.s mac_abs_802154.c mac_filtering.c nv_data.c nvm_adapter.c
  group nwk_ip/core/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface/: network_utils.h sockets.h stack_events.h
  group nwk_ip/core/interface/modules
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface/modules/: arp.h coap.h coap_cfg.h dhcp.h dhcp6.h dhcp6_cfg.h dhcp6_client.h dhcp6_lq_client.h dhcp6_lq_server.h dhcp6_relay_agent.h dhcp6_server.h dhcp_cfg.h dhcp_client.h dhcp_server.h dns_client.h dns_client_cfg.h dns_utils.h dtls.h dtls_cfg.h event_manager.h event_manager_cfg.h icmp.h icmp4.h icmp6.h igmp.h ip.h ip4.h ip6.h ip_cfg.h ip_if_management.h mdns.h mdns_cfg.h mle.h mle_basic.h mle_cfg.h mle_extended.h mle_security.h mle_utils.h mpl.h mpl_cfg.h nd.h nd_cfg.h nd_events.h nd_sixlowpan.h nd_tables.h pmtu_discovery.h rfc4944_6lowpan.h rfc6282_header_comp.h session.h sixlowpan.h sixlowpan_cfg.h sixlowpan_fwd_thread.h sixlowpan_ib.h sixlowpan_interface.h sixlowpan_tbl.h sockets_cfg.h stack_config.h stack_manager_if.h tcp.h tcp_cfg.h thread_stack_config.h trickle.h trickle_cfg.h udp.h udp_cfg.h version.h
  group nwk_ip/core/interface/thread
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/core/interface/thread/: thread_app_callbacks.h thread_attributes.h thread_cfg.h thread_meshcop.h thread_meshcop_mgmt.h thread_network.h thread_network_data.h thread_server_data.h thread_types.h thread_utils.h
  group nwk_ip/app/config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/common/: app_config.h app_framework_config.h app_mac_config.h app_stack_config.h app_thread_config.h
  group nwk_ip/app/common
    ../../../../../../../middleware/wireless/nwk_ip_1.2.1/examples/common/: app_coap_observe.c app_coap_observe.h app_echo_udp.c app_echo_udp.h app_event_monitoring.c app_event_monitoring.h app_init.c app_init.h app_led.c app_led.h app_observe_demo.c app_observe_demo.h app_socket_utils.c app_socket_utils.h app_temp_sensor.c app_temp_sensor.h app_thread_callbacks.c app_thread_init.c app_serial_tun.c app_serial_tun.h app_border_router.c app_border_router.h app_ethernet.c app_ethernet.h app_ethernet_usb.c app_ethernet_usb.h app_ota.h app_ota_client.c app_ota_server.c
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_common.h fsl_common.c fsl_rnga.c fsl_rnga.h fsl_flash.c fsl_flash.h fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_ftm.c fsl_ftm.h fsl_dspi.h fsl_dspi.c fsl_i2c.h fsl_i2c.c fsl_lptmr.c fsl_lptmr.h fsl_rtc.c fsl_rtc.h fsl_llwu.h fsl_llwu.c fsl_mpu.h fsl_mpu.c fsl_enet.h fsl_enet.c fsl_adc16.c fsl_adc16.h fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c
  group mmcau/mmcau_include
    ../../../../../../../middleware/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../../../middleware/mmcau_2.0.0/: fsl_mmcau.c
  group utilities
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
