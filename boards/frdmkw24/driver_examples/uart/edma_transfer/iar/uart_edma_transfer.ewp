# IAR project uart_edma_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 NXP MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKW24D5/drivers; ..; ../../../../../../devices/MKW24D5/utilities; ../../../../../../middleware/dma_manager_2.0.0; ../../../..; ../../../../../../devices/MKW24D5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: uart_edma_transfer.out
  ILINK.IlinkIcfFile: MKW24D512xxx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_uart_edma.h fsl_uart_edma.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: uart_edma_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
  group dma_manager
    ../../../../../../middleware/dma_manager_2.0.0/: fsl_dma_manager.c fsl_dma_manager.h
