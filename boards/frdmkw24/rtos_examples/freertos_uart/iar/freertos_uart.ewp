# IAR project freertos_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 NXP MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKW24D512VHA5; FSL_RTOS_FREE_RTOS; FRDM_KW24; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM3; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKW24D5/drivers; ..; ../../../../../devices/MKW24D5/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MKW24D5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_uart.out
  ILINK.IlinkIcfFile: MKW24D512xxx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW24D512VHA5; FSL_RTOS_FREE_RTOS; FRDM_KW24; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group drivers/freertos
    ../../../../../devices/MKW24D5/drivers/: fsl_uart_freertos.h fsl_uart_freertos.c
  group source
    ../: FreeRTOSConfig.h freertos_uart.c
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group board/board
    ../: pin_mux.c pin_mux.h
  group utilities
    ../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
