# IAR project dev_composite_hid_audio_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 NXP MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKW24D512VHA5; USB_STACK_BM; FRDM_KW24; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKW24D5/drivers; ..; ../../../../../../devices/MKW24D5/utilities; ../../../../../../middleware/usb_1.1.0; ../../../../../../middleware/usb_1.1.0/osa; ../../../../../../middleware/usb_1.1.0/include; ../../../../../../middleware/usb_1.1.0/device; ../../../..; ../../../../../../devices/MKW24D5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_composite_hid_audio_bm.out
  ILINK.IlinkIcfFile: MKW24D512xxx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKW24D512VHA5; USB_STACK_BM; FRDM_KW24; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.1.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.1.0/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/device/include
    ../../../../../../middleware/usb_1.1.0/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.1.0/include/: usb.h
  group drivers
    ../../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.1.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: audio_data.c audio_generator.c audio_generator.h composite.c composite.h mouse.c mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group utilities
    ../../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
