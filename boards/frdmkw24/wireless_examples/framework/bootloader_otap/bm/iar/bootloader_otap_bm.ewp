# IAR project bootloader_otap_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 NXP MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; gEepromType_d=gEepromDevice_AT45DB161E_c; gUseOTAPBootloader_d=1; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../src/bootloader; ../../src/eeprom; ../../src/flash; ../../src/config; ../../src/spi; ../../src/timer; ../../src/uart; ../../../../../../../devices/MKW24D5/drivers; ../../../../../../../devices/MKW24D5; ../../../../../../../middleware/wireless/framework_5.0.5/Common; ../../../../../../../devices/MKW24D5/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bootloader_otap_frdmkw24.bin
  ILINK.IlinkOutputFile: bootloader_otap_bm.out
  ILINK.IlinkConfigDefines: gRomSize_c=524288; gSectorSize_c=2048
  ILINK.IlinkIcfFile: Bootloader.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; gEepromType_d=gEepromDevice_AT45DB161E_c; gUseOTAPBootloader_d=1; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group source
    ../../src/bootloader/: main.c main.h OtapBootloader.c OtapBootloader.h
  group source/drivers/eeprom
    ../../src/eeprom/: Eeprom_Boot.h Eeprom_Boot_AT45DB161E.c
  group source/drivers/flash
    ../../src/flash/: flash_boot_kinetis.c flash_boot_kinetis.h
  group source/drivers/spi
    ../../src/spi/: SPI.c SPI.h
  group source/drivers/timer
    ../../src/timer/: timer.c timer.h
  group source/drivers/uart
    ../../src/uart/: UART.c UART.h
  group source/config
    ../../src/config/: frdmkw24_cfg.h
  group drivers
    ../../../../../../../devices/MKW24D5/drivers/: fsl_common.h fsl_common.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.0.5/Common/: EmbeddedTypes.h
  group utilities
    ../../../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
