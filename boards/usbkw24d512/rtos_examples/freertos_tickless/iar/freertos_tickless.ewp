# IAR project freertos_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 Freescale MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKW24D512VHA5; USB_STACK_BM; BOARD_USE_VIRTUALCOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM3; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKW24D5/drivers; ../../../../../devices/MKW24D5/utilities; ..; ../../../../../middleware/usb_1.1.0; ../../../../../middleware/usb_1.1.0/osa; ../../../../../middleware/usb_1.1.0/include; ../../../../../middleware/usb_1.1.0/device; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MKW24D5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_tickless.out
  ILINK.IlinkIcfFile: MKW24D512xxx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKW24D512VHA5; USB_STACK_BM; BOARD_USE_VIRTUALCOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW24D5/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_sim.h fsl_sim.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../middleware/usb_1.1.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb/device/source
    ../../../../../middleware/usb_1.1.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../middleware/usb_1.1.0/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/include
    ../../../../../middleware/usb_1.1.0/device/: usb_device.h
  group usb/include
    ../../../../../middleware/usb_1.1.0/include/: usb.h
  group source
    ../: FreeRTOSConfig.h freertos_tickless.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h virtual_com.c virtual_com.h usb_device_descriptor.c usb_device_descriptor.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h
